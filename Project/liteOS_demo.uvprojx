# Keil uVision project liteOS_demo.uvprojx, settings and files
target LiteOS_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: liteOS_demo +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\Lib\CMSIS\Include;..\Lib\FWlib\inc;..\User;..\LiteOS\cmsis;..\LiteOS\cmsis\1.0;..\LiteOS\cmsis\2.0;..\LiteOS\arch\arm\arm-m\include;..\LiteOS\kernel\base\include;..\LiteOS\kernel\extended\include;..\LiteOS\kernel\include;..\LiteOS\OS_CONFIG;..\bsp\LED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Lib/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Lib/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group liteos/cmsis
    ../LiteOS/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../LiteOS/kernel/base/mem/membox/: los_membox.c
    ../LiteOS/kernel/base/misc/: los_misc.c
    ../LiteOS/kernel/base/om/: los_err.c
    ../LiteOS/kernel/extended/tickless/: los_tickless.c
    ../LiteOS/kernel/: los_init.c
  group liteos/arch
    ../LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
    ../LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group log_config
    ../LiteOS/OS_CONFIG/: los_builddef.h los_printf.h target_config.h
  group Lib/FWLib
    ../Lib/FWlib/src/: stm32f10x_wwdg.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_dbgmcu.c stm32f10x_dac.c stm32f10x_crc.c stm32f10x_cec.c stm32f10x_can.c stm32f10x_bkp.c stm32f10x_adc.c misc.c
  group bsp
    ../bsp/LED/: led.c
